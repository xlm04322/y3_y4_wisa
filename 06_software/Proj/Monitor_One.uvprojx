# Keil uVision project Monitor_One.uvprojx, settings and files
target Monitor_One (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F030C8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Monitor_One +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, STM32F0XX_LD,
  c include: ..\ST_Lib\inc;..\ST_Lib\src;..\System\CMSIS;..\System\startup;..\User;..\My_Lib\delay;..\My_Lib\I2C;..\My_Lib\KEY;..\My_Lib\ADC;..\My_Lib\SPEAK;..\My_Lib\FLASH;..\My_Lib\PGA2311;..\My_Lib\USART1;..\My_Lib\USART2;..\My_Lib\24C02;D:\Keil_v5\ARM\ARMCC\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --libpath "D:\Keil_v5\ARM\ARMCC\lib"
  group User
    ../User/: main.c
  group My_Lib
    ../My_Lib/delay/: delay.c
    ../My_Lib/I2C/: i2c1.c EQ_V0.0.h
    ../My_Lib/KEY/: KEY.c
    ../My_Lib/SPEAK/: speak.c
    ../My_Lib/PGA2311/: PGA2311.c
    ../My_Lib/USART2/: USART2.c
    ../My_Lib/USART1/: USART1.c
    ../My_Lib/FLASH/: flash.c
  group System
    ../System/startup/: startup_stm32f030x8.s
    ../System/CMSIS/: core_cm0.h core_cm0plus.h stm32f0xx.h stm32f0xx_conf.h system_stm32f0xx.c system_stm32f0xx.h
  group ST-Lib
    ../ST_Lib/src/: stm32f0xx_adc.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_misc.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c
software components: CMSIS:CORE 4.3.0
